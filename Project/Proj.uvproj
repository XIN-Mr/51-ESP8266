# Keil uVision project Proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Proj
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP\DHT11;..\APP\oled;..\APP\Usart;..\APP\ESP8266;..\User;..\APP\time
  group User
    ../User/: main.c include.h
  group APP
    ../APP/DHT11/: DHT11.c
    ../APP/oled/: oled.c
    ../APP/Usart/: usart.c
    ../APP/time/: time.c
