# Keil uVision project OLED12864.uvproj, settings and files
target OLED12864 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: OLED12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51
    ./src/: main.c oled.c
