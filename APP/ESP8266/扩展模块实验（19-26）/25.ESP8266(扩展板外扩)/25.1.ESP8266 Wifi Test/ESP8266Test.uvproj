# Keil uVision project ESP8266Test.uvproj, settings and files
target ESP8266 WIFI (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ESP8266Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP.A51
  group Src
    ./src/: ds18b20.c main.c
